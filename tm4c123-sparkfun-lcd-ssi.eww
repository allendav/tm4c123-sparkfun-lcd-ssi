<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\tm4c123-sparkfun-lcd-ssi.ewp</path>
    </project>
    <batchBuild />
</workspace>
